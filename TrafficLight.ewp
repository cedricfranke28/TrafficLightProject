# IAR project TrafficLight.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Button.cpp Button.h GPIO.cpp GPIO.h IOperationState.h ITrafficLightInput.h ITrafficLightOutput.h ITrafficLightState.h LED.cpp LED.h main.cpp OS_InOperation.cpp OS_InOperation.h OS_OutOfOperation.h regtypes.h TLI_HardwareInput.h TLI_SoftwareInput.h TLO_HardwareOutput.h TLO_SoftwareOutput.cpp TLO_SoftwareOutput.h TLS_Amber.h TLS_Green.h TLS_Red.h TLS_RedAmber.h TrafficLightController.cpp TrafficLightController.h
